COMPATIBLE_MACHINE:versal-vck190-sdt-seg = "${MACHINE}"

IMAGE_B_OFFSET:versal-vck190-sdt-seg = "0x47C_0000"
USER_SCRATCHPAD_OFFSET:versal-vck190-sdt-seg = "0x7A0_0000"
SPI_SIZE:versal-vck190-sdt-seg = "0x800_0000"
