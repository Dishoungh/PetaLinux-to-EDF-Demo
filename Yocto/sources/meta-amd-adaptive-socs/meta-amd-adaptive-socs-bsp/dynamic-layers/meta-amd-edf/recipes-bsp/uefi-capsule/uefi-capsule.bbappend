COMPATIBLE_MACHINE:versal-vek280-sdt-seg = "${MACHINE}"
COMPATIBLE_MACHINE:versal-2ve-2vm-vek385-sdt-seg = "${MACHINE}"
COMPATIBLE_MACHINE:versal-2ve-2vm-vek385-revb-sdt-seg = "${MACHINE}"
COMPATIBLE_MACHINE:versal-vrk160-sdt-seg = "${MACHINE}"

UEFI_CAB_GUID:versal-vrk160-sdt-seg = "f1c0d5e8-7a23-4b91-b0f8-3e5c6a2d97f3"
UEFI_CAB_GUID:versal-vek280-sdt-seg = "a1f0d8c9-b3a7-4e09-9f25-7c9823b8a6f2"
UEFI_CAB_GUID:versal-2ve-2vm-vek385-sdt-seg = "cb27e54d-8f3a-4c77-8a72-1c76d2d4e938"
UEFI_CAB_GUID:versal-2ve-2vm-vek385-revb-sdt-seg = "f27c2e59-8f43-4d77-9b63-12b0a4e67c28"
