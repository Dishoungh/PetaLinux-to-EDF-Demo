CFLAGS:append:versal-vck190-sdt-seg = " -DXIS_QSPI_FLSH"
CFLAGS:append:versal-2ve-2vm-vek385-revb-sdt-seg = " -DXIS_ENABLE_PB"
