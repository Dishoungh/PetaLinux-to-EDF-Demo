inherit esw

ESW_COMPONENT_SRC = "/lib/sw_services/xiltpm/src/"
ESW_COMPONENT_NAME = "libxiltpm.a"

DEPENDS += " \
    xilsecure \
    "
