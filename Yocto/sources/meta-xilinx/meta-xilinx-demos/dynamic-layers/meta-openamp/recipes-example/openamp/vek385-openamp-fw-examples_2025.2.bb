SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2025.2/edf_files/2025.2/11150857/external/openamp-zephyr-demo/versal-2ve-2vm-vek385-sdt-seg_openamp-zephyr-demo_11150857.tar.gz"
SRC_URI[sha256sum] = "a2387de23a7e50db41ba30581290d9aa903262dfccf71dbb29b4bab7631a48cb"

require conf/includes/openamp-fw-example.inc
