
require qemu-devicetrees.inc

BRANCH ?= "xlnx_rel_v2025.2"
SRCREV ?= "075383c583d3c4ed7ed19b8dc45cd12e391eca1b"

