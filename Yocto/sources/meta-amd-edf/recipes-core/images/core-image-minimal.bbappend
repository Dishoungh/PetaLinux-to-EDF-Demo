# Add cpio.gz to use as ramdisk image.
IMAGE_FSTYPES += "cpio.gz"
