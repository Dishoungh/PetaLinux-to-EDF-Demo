RDEPENDS:${PN}:remove:amd-edf = "dhcpcd"
