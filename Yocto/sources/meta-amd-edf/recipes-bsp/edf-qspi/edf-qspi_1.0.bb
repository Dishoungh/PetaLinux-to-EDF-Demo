SUMMARY = "QSPI image for AMD Embedded Development Framework"
DESCRIPTION = "QSPI image for AMD Embedded Development Framework with image selector, image recovery, capsule metadata and boot.bin"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

IMAGE_SELECTOR_OFFSET ?= "0x0"
IMAGE_SELECTOR_BACKUP_OFFSET ?= "0x6_0000"
IMAGE_SELECTOR_SCRATCHPAD_OFFSET ?= "0xC_0000"
IMAGE_RECOVERY_OFFSET ?= "0xE_0000"
IMAGE_RECOVERY_META_OFFSET ?= "0x14E_0000"
CAPSULE_METADATA_OFFSET ?= "0x150_0000"
CAPSULE_METADATA_BACKUP_OFFSET ?= "0x152_0000"
UBOOT_ENV_OFFSET ?= "0x154_0000"
UBOOT_ENV_BACKUP_OFFSET ?= "0x156_0000"
IMAGE_A_OFFSET ?= "0x158_0000"
IMAGE_B_OFFSET ?= "0x25C_0000"
USER_SCRATCHPAD_OFFSET ?= "0x360_0000"
SPI_SIZE ?= "0x400_0000"

inherit amd-edf-spi-image

COMPATIBLE_MACHINE = "^$"

PACKAGE_ARCH = "${MACHINE_ARCH}"
