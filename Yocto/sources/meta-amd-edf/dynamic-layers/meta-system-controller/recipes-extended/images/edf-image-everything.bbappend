AMD_CORTEXA53_INSTALL += " \
    packagegroup-syscontroller \
    packagegroup-scweb \
    packagegroup-systemcontroller-boards \
    libubootenv \
    libubootenv-bin \
    mmc-utils \
    udev-extraconf \
    ser2net \
    picocom \
    embpf-bootfw-update-tool \
    python3-frugy \
    sc-usb-gadget \
    "
