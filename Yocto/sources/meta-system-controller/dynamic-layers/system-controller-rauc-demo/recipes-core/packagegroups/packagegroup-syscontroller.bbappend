SYSTEM_CONTROLLER_PACKAGES:append:system-controller-rauc-demo = " \
	rauc \
	rauc-service \
	rauc-mark-good \
	"
