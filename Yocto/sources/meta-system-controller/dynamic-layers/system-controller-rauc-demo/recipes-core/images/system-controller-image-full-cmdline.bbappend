IMAGE_INSTALL:append:system-controller-rauc-demo = " rauc rauc-service rauc-mark-good"
