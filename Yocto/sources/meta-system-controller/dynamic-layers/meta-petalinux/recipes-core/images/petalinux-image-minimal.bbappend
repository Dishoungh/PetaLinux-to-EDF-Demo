require petalinux-image-common-sc.inc
