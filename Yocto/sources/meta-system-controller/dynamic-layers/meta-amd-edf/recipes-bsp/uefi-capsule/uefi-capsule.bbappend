COMPATIBLE_MACHINE:zynqmp-k24-sc-sdt-base = "${MACHINE}"
