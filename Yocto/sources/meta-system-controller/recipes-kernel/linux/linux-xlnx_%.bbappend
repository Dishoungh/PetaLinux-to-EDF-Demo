INC_FILE = ""
INC_FILE:system-controller = "linux-xlnx-sc.inc"

require ${INC_FILE}
