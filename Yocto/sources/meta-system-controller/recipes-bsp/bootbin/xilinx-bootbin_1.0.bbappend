BOOTBIN_INCLUDE:system-controller = "xilinx-bootbin-sc.inc"

include ${BOOTBIN_INCLUDE}
