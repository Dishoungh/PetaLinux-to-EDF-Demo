require recipes-extended/images/container-app-base.bb

# Hello world example from meta-skeleton
CONTAINER_APP = " hello"

CONTAINER_APP_CMD = "hello"
