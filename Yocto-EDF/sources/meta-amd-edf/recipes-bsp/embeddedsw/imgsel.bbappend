IMGSEL_MC = "${MACHINE}-microblaze-pmc"
IMGSEL_MC:zynqmp = "${MACHINE}-cortexa53-fsbl"
IMGSEL_DEPLOY_DIR = "${TMPDIR}-${IMGSEL_MC}/deploy/images/${MACHINE}"
