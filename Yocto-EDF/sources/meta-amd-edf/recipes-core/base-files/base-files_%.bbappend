AMD-EDF_INC = ""
AMD-EDF_INC:amd-edf = "base-files-edf.inc"
require ${AMD-EDF_INC}
