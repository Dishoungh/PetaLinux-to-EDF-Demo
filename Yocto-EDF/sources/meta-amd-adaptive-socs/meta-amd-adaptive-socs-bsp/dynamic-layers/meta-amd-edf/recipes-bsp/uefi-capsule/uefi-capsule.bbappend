COMPATIBLE_MACHINE:versal-vek280-sdt-seg = "${MACHINE}"

UEFI_CAB_GUID:versal-vek280-sdt-seg = "a1f0d8c9-b3a7-4e09-9f25-7c9823b8a6f2"
