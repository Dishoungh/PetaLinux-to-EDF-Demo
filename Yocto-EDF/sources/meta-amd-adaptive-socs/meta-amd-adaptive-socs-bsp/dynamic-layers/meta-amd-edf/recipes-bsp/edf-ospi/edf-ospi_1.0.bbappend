COMPATIBLE_MACHINE:versal-vek280-sdt-seg = "${MACHINE}"
