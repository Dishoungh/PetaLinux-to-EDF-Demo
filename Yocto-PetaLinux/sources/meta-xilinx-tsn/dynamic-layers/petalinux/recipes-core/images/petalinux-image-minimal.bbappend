require petalinux-image-common-tsn.inc
