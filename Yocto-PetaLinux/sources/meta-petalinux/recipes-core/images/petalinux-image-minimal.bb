DESCRIPTION = "OSL image definition for Xilinx boards"
LICENSE = "MIT"

require petalinux-image-common.inc

IMAGE_NAME_SUFFIX ?= ""
