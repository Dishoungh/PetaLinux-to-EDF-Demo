RDEPENDS:${PN}:append = " \
	xclock \
	xcursor-transparent-theme \
	xeyes \
	xinit \
	xinput \
	xkbcomp \
	xkeyboard-config \
	xkeyboard-config-locale-en-gb \
	liberation-fonts \
"
