FILESEXTRAPATHS:prepend:versal-vek280-sdt-seg := "${THISDIR}/files:"
